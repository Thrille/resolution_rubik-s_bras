Commit message: test r&alisé

File: cubeV2.urdf (robot description, URDF)
Before this commit: robot cube, 2 links, 1 joints
Joints:
- joint base_to_right_leg: axis 0 0 -1 -> 0 -1 0
