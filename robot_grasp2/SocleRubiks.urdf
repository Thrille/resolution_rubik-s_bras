Commit message: concave collision

File: robot_grasp2/SocleRubiks.urdf (robot description, URDF)
Before this commit: robot socle, 1 links, 0 joints
Links:
- link socle: geometry collision mesh filename=socle.stl scale=0.001 0.001 0.001; visual mesh filename=socle.stl scale=0.001 0.001 0.001
